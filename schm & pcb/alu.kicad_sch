File: schm & pcb/alu.kicad_sch (KiCad schematic)
At the start: 43 parts

Commit message: update from mac
Parts:
- gave numbers to parts that had none: 29
